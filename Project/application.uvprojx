# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051QN20 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CMSIS\Include;..\Device\Include;..\Device\Source;..\Driver\inc;..\User\App;..\User\Drv;..\User\Hal
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../Device/Source/ARM/: startup_CMS32L051.s
  group Cmsis
    ../Device/Source/: system_CMS32L051.c
  group Library
    ../Driver/src/: clk.c gpio.c
  group App
    ../User/App/: main.c
